# Keil uVision project tx-cw.uvprojx, settings and files
target tx-cw-eu868 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: tx-cw-eu868 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L053xx REGION_EU868
  c include: ..\..\..\src;..\..\..\src\boards\NucleoL053;..\..\..\src\boards\NucleoL053\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\inc;..\..\..\src\mac;..\..\..\src\peripherals;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group apps
    ../../../src/apps/tx-cw/NucleoL053/: main.c
  group boards\NucleoL053
    ../../../src/boards/NucleoL053/: board.c gpio-board.c rtc-board.c spi-board.c sx126x-board.c uart-board.c
  group boards\NucleoL053\cmsis
    ../../../src/boards/NucleoL053/cmsis/arm-std/: startup_stm32l053xx.s
    ../../../src/boards/NucleoL053/cmsis/: system_stm32l0xx.c
  group boards\NucleoL053\STM32L0xx_HAL_Driver
    ../../../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group radio
    ../../../src/radio/sx126x/: radio.c sx126x.c
  group system
    ../../../src/system/: delay.c fifo.c gpio.c timer.c uart.c
target tx-cw-us915 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: as above
  output: tx-cw-us915 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L053xx REGION_US915
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
